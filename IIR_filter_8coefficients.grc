options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Embedded_Python_Example_IIR_Filter
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32E3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        self.set_history(8)  #Example: The comand set_history(4) appends the previous 4-1=3 items to the input buffer (input_items), while the 4'th item is the current value. Therefore,\n            #input_items[0][3] is the beginning of the current input stream.\n            #input_items[0][2] is one input older than the current input stream.\n            #input_items[0][1] is one input older than input_items[0][2]\n            #input_items[0][0] is one input older than input_items[0][1]\n        self.outputbuffer = [0,0,0,0,0,0,0] #This is a local array that I define to store old output values. I need to set this up since there is not a set_history function to access old outputs (at least I cannot find such a function in GNU radio).\n        self.feedforward_taps= 0.0736, 0.2208, 0.2208, 0.0736, 0.5, 0.4, -0.3, 0.2 #feedforward taps of IIR filter\n        self.feedbacktaps= 1.0000, -0.9761, 0.8568, -0.2919, 0.51, -0.41, 0.31, 0.21 #feedback taps of IIR filter\n        \n    def work(self, input_items, output_items):\n\n        #Here I create a new list called output_items_with_history, which appends the previous 3 items to the current output_items. The properties of this new list are as follows:\n        #output_items_with_history[3] is the beginning of the current output stream.\n        #output_items_with_history[2] is one output older than the current output stream.\n        #output_items_with_history[1] is one output older than output_items_with_history[2]\n        #output_items_with_history[0] is one input older than output_items_with_history[1]\n        \n        #To create output_items_with_history, I tried doing the following command:\n        #output_items_with_history=self.outputbuffer+output_items[0][:]... but it doesn't work, so I came up with the following non-elegant way to create output_items_with_history:\n        output_items_with_history=[0]\n        output_items_with_history.extend(self.outputbuffer)\n        output_items_with_history.extend(output_items[0][:])\n        output_items_with_history=output_items_with_history[1:]\n\n        #Implement IIR difference equation to filter. Keep in mind that output_items_with_history[3] is the beginning of the current output stream, and input_items[0][3] is the beginning of the current input stream.\n        for i in range(0, len(output_items_with_history)-7):\n            output_items_with_history[i+7]=input_items[0][i+7]*self.feedforward_taps[0] + input_items[0][i+6]*self.feedforward_taps[1] + \\\n                                           input_items[0][i+5]*self.feedforward_taps[2] + input_items[0][i+4]*self.feedforward_taps[3] + \\\n                                           input_items[0][i+3]*self.feedforward_taps[4]+input_items[0][i+2]*self.feedforward_taps[5]+\\\n                                           input_items[0][i+1]*self.feedforward_taps[6]+input_items[0][i]*self.feedforward_taps[7]-\\\n                                           output_items_with_history[i+6]*self.feedbacktaps[0]-output_items_with_history[i+5]*self.feedbacktaps[1]-\\\n                                           output_items_with_history[i+4]*self.feedbacktaps[2]-output_items_with_history[i+3]*self.feedbacktaps[3]-\\\n                                           output_items_with_history[i+2]*self.feedbacktaps[4]-output_items_with_history[i+1]*self.feedbacktaps[5]-\\\n                                           output_items_with_history[i]*self.feedbacktaps[6]\n\n        output_items[0][:]=output_items_with_history[7:] #Populate our output_items array\n        \n        end_of_the_road=len(output_items[0]) #length of output item vector\n        self.outputbuffer[6] = output_items[0][end_of_the_road-1]  # The last element of the outputbuffer is the last output item\n        self.outputbuffer[5] = output_items[0][end_of_the_road-2]  # The second to last element of the outputbuffer is the second to last output item\n        self.outputbuffer[4] = output_items[0][end_of_the_road-3]  # The third to last element of the outputbuffer is the third to last output item\n        self.outputbuffer[3]=output_items[0][end_of_the_road-4] #The last element of the outputbuffer is the last output item\n        self.outputbuffer[2]=output_items[0][end_of_the_road-5]#The second to last element of the outputbuffer is the second to last output item\n        self.outputbuffer[1]=output_items[0][end_of_the_road-6] #The third to last element of the outputbuffer is the third to last output item\n        self.outputbuffer[0] = output_items[0][end_of_the_road - 7]\n        \n        return len(output_items[0])\n\n"
    example_param: '1'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1.0000,   -0.9761,    0.8568,  -0.2919, 0.51, -0.41, 0.31, 0.21]'
    fftaps: '[0.0736,    0.2208,    0.2208,    0.0736, 0.5, 0.4, -0.3, 0.2]'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    grid: 'True'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', iir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [iir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
